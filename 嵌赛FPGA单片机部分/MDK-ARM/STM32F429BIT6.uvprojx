# Keil uVision project STM32F429BIT6.uvprojx, settings and files
target STM32F429BIT6 (6220000::V6.22::ARMCLANG)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: STM32F429BIT6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,RTT_USE_ASM=0
  c misc: -Wno-invalid-source-encoding
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;./HardWare;./RTT;../SEGGER_RTT_V782b/RTT;../SEGGER_RTT_V782b/Config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: led.c key.c lcd_fonts.c lcd_image.c touch_iic.c touch_800x480.c UI.c UI_Data.c lcd_test.c main.c gpio.c adc.c dma.c dma2d.c fmc.c ltdc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
    ../Core/Inc/: UI.h touch_iic.h
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group HardWare
    ./HardWare/: KEY_1.c KEY_1.h Window_DSP.c Window_DSP.h
  group RTT
    ./RTT/: rtt_log.c rtt_log.h rtt_log_config.h
    ../SEGGER_RTT_V782b/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_printf.c
    ../SEGGER_RTT_V782b/Config/: SEGGER_RTT_Conf.h
  group Instrument
    ../Core/Inc/: instrument_config.h protocol_crc.h pressure_acq.h pressure_link.h instrument_protocol.h control_client.h control_transport.h instrument_settings.h instrument_ui.h touch_piano.h pca9555_keys.h pca9555_bus.h piano_input.h viz_frame.h viz_link.h viz_view.h
    ../Core/Src/: protocol_crc.c pressure_acq.c pressure_link.c instrument_protocol.c control_client.c control_transport.c instrument_settings.c instrument_ui.c touch_piano.c pca9555_keys.c pca9555_bus.c piano_input.c viz_frame.c viz_link.c viz_view.c
software components: CMSIS:CORE 5.0.1, CMSIS:DSP 1.5.1
